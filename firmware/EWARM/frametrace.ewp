# IAR project frametrace.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: ..\Core\Inc; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\Middlewares\FreeRTOS-Kernel\include; ..\Middlewares\FreeRTOS-Kernel\portable\IAR\ARM_CM4F; ..\Middlewares\SEGGER\Config; ..\Middlewares\SEGGER\SystemView\SEGGER; ..\Middlewares\SEGGER\SystemView\SYSVIEW; ..\Middlewares\SEGGER\SystemView\Sample\FreeRTOSV11; ..\Middlewares\SEGGER\RTT
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Core\Inc
  ILINK.IlinkOutputFile: frametrace.out
  ILINK.IlinkIcfFile: stm32f407vg_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F407xx; HSE_VALUE=8000000
  ICCARM.CCOptLevel: 3
  group Application/Inc
    ../Core/Inc/: app_trace.h button.h button_task.h command.h main.h protocol.h queue_exp.h queue_exp_core.h arda.h port_config.h port_layer.h health.h frame_timer.h mem_layout.h stats.h system_clock.h telemetry_task.h temp_sensor.h timestamp.h tx_queue.h uart.h uart_tx_task.h workload.h
  group Application/Src
    ../Core/Src/: app_trace.c button.c button_task.c command.c main.c protocol.c queue_exp.c arda.c port_config.c port_layer.c health.c frame_timer.c stats.c stm32f4xx_it.c system_clock.c telemetry_task.c temp_sensor.c timestamp.c tx_queue.c uart.c uart_tx_task.c workload.c
  group CMSIS/Core
    ../Drivers/CMSIS/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h
  group CMSIS/Device
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include/: stm32f407xx.h stm32f4xx.h system_stm32f4xx.h
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Config
    ../Core/Inc/: FreeRTOSConfig.h
  group FreeRTOS
    ../Middlewares/FreeRTOS-Kernel/: list.c queue.c tasks.c
  group FreeRTOS/include
    ../Middlewares/FreeRTOS-Kernel/include/: deprecated_definitions.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group FreeRTOS/portable
    ../Middlewares/FreeRTOS-Kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group Startup
    ../Core/Startup/: startup_stm32f407xx.s
  group SEGGER/Config
    ../Middlewares/SEGGER/Config/: Global.h SEGGER_RTT_Conf.h SEGGER_SYSVIEW_Conf.h SEGGER_SYSVIEW_Config_FreeRTOS.c
  group SEGGER/FreeRTOSV11
    ../Middlewares/SEGGER/SystemView/Sample/FreeRTOSV11/: SEGGER_SYSVIEW_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.h
  group SEGGER/RTT
    ../Middlewares/SEGGER/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_ConfDefaults.h
  group SEGGER/SystemView
    ../Middlewares/SEGGER/SystemView/SEGGER/: SEGGER.h
    ../Middlewares/SEGGER/SystemView/SYSVIEW/: SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_Int.h
